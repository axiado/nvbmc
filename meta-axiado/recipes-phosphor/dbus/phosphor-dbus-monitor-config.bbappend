PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " snmp-policy"
