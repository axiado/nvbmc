FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-SNMP-trap-failure-for-64-bit-ASN_OPAQUE_U64-vari.patch"

