RDEPENDS:${PN}-network += " ax-net iptables iproute2 net-tools"
RDEPENDS:${PN}-extras += " \
                          axiado-eip-firmware \
                          boot-state \
                          entity-manager \
                          klogmgr \
                          sysproxy \
                          tcu-reset \
                          tdfu \
                          phosphor-snmp \
                          snmp-policy \
                          phosphor-dbus-monitor \
                          "
                         
