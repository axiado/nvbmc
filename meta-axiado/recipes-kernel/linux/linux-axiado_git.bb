SRCREV = "65c8635e66a2e078f1a572e5c169d6e5e2572f04"

require linux-axiado.inc
